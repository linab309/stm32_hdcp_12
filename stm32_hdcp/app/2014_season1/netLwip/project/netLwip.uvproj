# Keil uVision project netLwip.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: netLwip +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_STM32_BR100
  c include: ..\;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\src;..\..\..\..\Utilities;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\Ports;..\ucCos_App;..\ENC28J60;..\lwip-1.3.2;..\lwip-1.3.2\src;..\lwip-1.3.2\src\include\lwip;..\lwip-1.3.2\src\include\arch;..\lwip-1.3.2\src\include\ipv4\lwip;..\lwip-1.3.2\src\include;..\lwip-1.3.2\src\arch;..\lwip-1.3.2\src\include\netif;..\lwip-1.3.2\src\netif
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../: lib.c main.c stm32f10x_it.c
  group ucos
    ../../../../Utilities/uCOS-II/Ports/: os_cpu_a.asm
    ../../../../Utilities/uCOS-II/uC-CPU/: cpu_a.asm
  group user
    ../lwip-1.3.2/src/: search.c
    ../ucCos_App/: uctsk_LWIP.c uctsk_Blink.c OS_AppHooks.c
  group enc28j60
    ../ENC28J60/: enc28j60.c
  group LWIP_core
    ../lwip-1.3.2/src/core/: dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c nbns.c
    ../lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.3.2/src/netif/: etharp.c
  group LWIP_arch
    ../lwip-1.3.2/src/: lwip.c
    ../lwip-1.3.2/src/arch/: sys_arch.c
    ../lwip-1.3.2/src/netif/: ethernetif.c
  group LWIP_api
    ../lwip-1.3.2/src/api/: sockets.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
